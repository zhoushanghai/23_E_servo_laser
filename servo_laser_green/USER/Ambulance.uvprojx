# Keil uVision project Ambulance.uvprojx, settings and files
target Ambulance (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Ambulance +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40 STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\MALLOC;..\USMART;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\ST7789;..\HARDWARE\DMA;..\HARDWARE\BEEPER;..\HARDWARE\Random;..\HARDWARE\Key;..\FWLIB\inc;..\HARDWARE\Control;..\HARDWARE\Encoder;..\HARDWARE\PWM;..\HARDWARE\Motor;..\HARDWARE\MPU6050;..\HARDWARE\gray_serial;..\HARDWARE\Servo;..\HARDWARE\menu
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Key/: Key.h
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/ST7789/: ST7789_Init.c ST7789_Init.h lcd.c lcd.h
    ../HARDWARE/DMA/: MyDMA.c MyDMA.h
    ../HARDWARE/BEEPER/: BEEPER.c BEEPER.h
    ../HARDWARE/Random/: Random.c Random.h
    ../HARDWARE/Motor/: Motor.c Motor.h control.c control.h pid.c pid.h
    ../HARDWARE/Encoder/: Encoder.c Encoder.h
    ../HARDWARE/PWM/: PWM.c PWM.h
    ../HARDWARE/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h mpu6050.c mpu6050.h myiic.c myiic.h
    ../HARDWARE/gray_serial/: gw_gray_serial.c gw_gray_serial.h
    ../HARDWARE/Servo/: Servo.c Servo.h
    ../HARDWARE/menu/: menu.c menu.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_sdio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_dcmi.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: readme.txt
